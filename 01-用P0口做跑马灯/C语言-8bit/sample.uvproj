# Keil uVision project sample.uvproj, settings and files
target Sample (MCS-51)
  device: AI8051U-8Bit Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: sample +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: main.c 功能说明.txt
